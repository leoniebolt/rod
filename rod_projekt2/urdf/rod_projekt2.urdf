Commit message: overwrote sth?j

File: rod_projekt2/urdf/rod_projekt2.urdf (robot description, URDF)
Before this commit: robot rod_projekt2, 20 links, 19 joints
Links:
- link world: mass 0.001 -> None
