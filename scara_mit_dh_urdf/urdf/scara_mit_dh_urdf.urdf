Commit message: Korrektur

File: scara_mit_dh_urdf/urdf/scara_mit_dh_urdf.urdf (robot description, URDF)
Before this commit: robot scara_mit_dh_urdf, 6 links, 5 joints
Joints:
- joint fixedToWorld: origin xyz=0 0 1 rpy=0 0 0 -> xyz=0 0 1 rpy=-1.57 0 0
